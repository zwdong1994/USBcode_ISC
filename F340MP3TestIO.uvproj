# Keil uVision project F340MP3TestIO.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: F340MP3TestIO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c NandFlash.c
  group USB
    ./: Usb_Function.c Usb_Isr.c Usb_Setup.c Bulk_Only.c
